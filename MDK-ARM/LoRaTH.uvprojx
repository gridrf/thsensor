# Keil uVision project LoRaTH.uvprojx, settings and files
target LoRaTH (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRaTH
  c flags: OneElfS=1 wLevel=2
  c define: USE_FULL_ASSERT,USE_HAL_DRIVER,STM32L151xB,REGION_CN470
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;..\Src\board;..\Src;..\Src\system;..\Src\radio\sx1276;..\Src\radio;..\Src\system\crypto;..\Src\mac;..\Src\mac\region
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  link misc: --diag_suppress=L6329
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_cortex.c stm32l1xx_hal_flash.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_pwr.c stm32l1xx_hal_i2c.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_rcc.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_gpio.c stm32l1xx_hal.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c
  group Board
    ../Src/board/: board.c spi-board.c gpio-board.c i2c-board.c rtc-board.c sx1276-board.c sht3x-board.c led-board.c uart-board.c rs485-board.c
  group System
    ../Src/system/: delay.c fifo.c i2c.c timer.c gpio.c
  group Radio
    ../Src/radio/sx1276/: sx1276.c
  group mac
    ../Src/mac/: LoRaMac.c LoRaMacCrypto.c
  group System/crypto
    ../Src/system/crypto/: aes.c cmac.c
  group mac/region
    ../Src/mac/region/: Region.c RegionCommon.c RegionCN470.c
  group Application/MDK-ARM
    ./: startup_stm32l151xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Application/User
    ../Src/: main.c stm32_tm1637.c Font_7Seg.c utilities.c uart.c
software components: CMSIS:CORE 4.1.0
